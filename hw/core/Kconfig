## hw/core/Kconfig
```kconfig
config EMPTY_SLOT
    bool

config PTIMER
    bool

config FITLOADER
    bool

config PLATFORM_BUS
    bool

config FSL_MC_BUS
    bool
```
